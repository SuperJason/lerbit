# Keil uVision project data.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_hts +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER
  c misc: --c99
  c include: ..;..\Include;..\Include\app_common;..\Include\ble;..\Include\ble\ble_services;..\Include\ble\softdevice;..\SourceCode
  memory RVCT4: ROM 0x14000 size 0x2c000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ../SetupCode/: system_nrf51.c arm_startup_nrf51.s
  group Source Code
    ../SourceCode/: data.c
  group Services
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/ble/ble_services/: ble_bas.c ble_dis.c ble_hts.c
  group Libraries
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/ble/: ble_advdata.c ble_sensorsim.c ble_stack_handler.c ble_conn_params.c ble_bondmngr.c ble_flash.c ble_error_log.c ble_radio_notification.c ble_debug_assert_handler.c
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/ble/ble_services/: ble_srv_common.c
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/app_common/: app_timer.c app_button.c app_gpiote.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: as above
  output: ble_app_hts +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\softdevice
  memory RVCT4: ROM 0x14000 size 0xc000
  memory RVCT9: RAM 0x20002000 size 0x2000
