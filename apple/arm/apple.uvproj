# Keil uVision project apple.uvproj, settings and files
target Nordic51822_Cherry (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: cherry +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER
  c misc: --c99
  c include: ..\Include;..\Include\app_common;..\Include\ble;..\Include\ble\ble_services;..\Include\ble\softdevice;..\Include\boards;..\Include\esb;..\Include\ext_sensors;..\Include\gzll;..\Include\gzp;..\SourceCode
  memory RVCT4: ROM 0x14000 size 0x2c000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group StartupCode
    ../SetupCode/: system_nrf51.c arm_startup_nrf51.s
  group SourceCode
    ../SourceCode/: apple.c lerbit_ped.c
  group Libraries
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/spi_master/: spi_master.c
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/twi_master/: twi_hw_master.c
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/app_common/: app_timer.c app_button.c app_gpiote.c
