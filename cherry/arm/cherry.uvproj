# Keil uVision project cherry.uvproj, settings and files
target Nordic51822_Cherry (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: cherry +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER
  c misc: --c99
  c include: ..\Include;..\Include\app_common;..\Include\ble;..\Include\ble\ble_services;..\Include\ble\softdevice;..\Include\boards;..\Include\esb;..\Include\ext_sensors;..\Include\gzll;..\Include\gzp;..\SourceCode
  memory RVCT4: ROM 0x14000 size 0x2c000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group StartupCode
    ../SetupCode/: system_nrf51.c arm_startup_nrf51.s
  group SourceCode
    ../SourceCode/: cherry.c cherry_app_timer.c
  group Services
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/ble/ble_services/: ble_tps.c ble_ias.c ble_lls.c ble_bas.c ble_ias_c.c
  group Libraries
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/app_common/: app_button.c app_gpiote.c
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/ble/: ble_error_log.c ble_advdata.c ble_conn_params.c ble_stack_handler.c ble_bondmngr.c ble_flash.c ble_radio_notification.c ble_sensorsim.c
    C:/Keil/ARM/Device/Nordic/nrf51822/Source/ble/ble_services/: ble_srv_common.c
